File: hardware/ddr3.kicad_sch (KiCad schematic)
At the start: 22 parts, among them U2 H5TQ4G63EFR

Commit message: Finished with V1!
Parts:
- U2: LCSC Part # C2803259 -> C2803248
